# Keil uVision project STM32F407_Base - 副本.uvprojx, settings and files
target Coffee2Open (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Coffee2Open +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_COFFEE2,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x0000C000U
  c misc: --preinclude ..\Application\UserAPP\Coffee2App\Config\coffee2_build_config.h
  c include: ../CubeMX_Base/Core/Inc;..\Application\Common;../Application/DeviceLibrary/Inc;../Application/DeviceLibrary/Robot/Dobot;../Application/DeviceLibrary/CoffeeMachine;../Application/DeviceLibrary/CupLidController/ShengShu;../Application/DeviceLibrary/SyrupMachine/CurrentModbus;../Application/DeviceLibrary/IceMachine/CurrentModbus;../Application/DeviceLibrary/Scale/BSQ_DG_V2;../Application/DeviceLibrary/PowerMeter/DDSU666;../Application/DeviceLibrary/IoModule/ModbusDigitalIo;../Application/Common/Diagnostics/Inc;../Application/Common/Diagnostics/Config;../Application/UserAPP/Coffee2App/Config;../Application/UserAPP/Coffee2App/Task_Manager;../Application/UserAPP/Coffee2App/Comm_Log;../Application/UserAPP/Coffee2App/Device;../Application/UserAPP/Coffee2App/IO_State;../Application/UserAPP/Coffee2App/Modbus_Rtu_Bus;../Application/UserAPP/Coffee2App/Robot_Tcp;../Application/UserAPP/Coffee2App/Modbus_Tcp_Server;../Application/UserAPP/Coffee2App/Ota;../Application/UserAPP/Coffee2App/WorkFlow;../Application/Transport/Inc;../Application/ProtocolStack/ModbusPort/Inc;../Application/ProtocolStack/ModbusPort/Config;..\Application\New_Party\nanoMODBUS\Inc;..\Application\New_Party\nanoMODBUS\Config;../CubeMX_Base/LWIP/App;../CubeMX_Base/LWIP/Target;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include;../CubeMX_Base/Middlewares/Third_Party/LwIP/system;../CubeMX_Base/Drivers/STM32F4xx_HAL_Driver/Inc;../CubeMX_Base/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/include;../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../CubeMX_Base/Drivers/BSP/Components/dp83848;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/netif/ppp;../CubeMX_Base/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/lwip;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/lwip/apps;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/lwip/priv;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/lwip/prot;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/netif;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/compat/posix;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/compat/stdc;../CubeMX_Base/Middlewares/Third_Party/LwIP/system/arch;../CubeMX_Base/Drivers/CMSIS/Include
  asm include: ../CubeMX_Base/Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\ScatterFiles\Coffee2_CCM.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../CubeMX_Base/Core/Src/: main.c gpio.c freertos.c crc.c dma.c rtc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/LWIP/Target
    ../CubeMX_Base/LWIP/Target/: ethernetif.c
  group Application/User/Diagnostics
    ../Application/Common/Diagnostics/Src/: app_crash_diag.c app_crash_fault_armcc.s
  group Application/Common
    ../Application/Common/Log/: app_log.c
    ../Application/Common/LwipAlert/: app_lwip_alert.c
    ../Application/Common/Ota/: app_ota_flash.c app_ota_http.c
    ../Application/Common/TcpClientSession/: tcp_client_session.c
  group Application/Coffee2App
    ../Application/UserAPP/Coffee2App/Config/: coffee2_device_bindings.h
    ../Application/UserAPP/Coffee2App/Comm_Log/: coffee2_log.c coffee2_crash_log_port.c coffee2_retarget.c
    ../Application/UserAPP/Coffee2App/Device/: coffee2_device.c coffee2_device_image.c
    ../Application/UserAPP/Coffee2App/IO_State/: coffee2_io.c
    ../Application/UserAPP/Coffee2App/Modbus_Rtu_Bus/: coffee2_rtu_bus.c
    ../Application/UserAPP/Coffee2App/Robot_Tcp/: coffee2_robot_tcp.c
    ../Application/UserAPP/Coffee2App/Modbus_Tcp_Server/: coffee2_server.c
    ../Application/UserAPP/Coffee2App/WorkFlow/: coffee2_workflow.c
    ../Application/UserAPP/Coffee2App/Task_Manager/: coffee2_manager.c
    ../Application/UserAPP/Coffee2App/Ota/: coffee2_ota.c
  group Application/Coffee3CloseApp
    ../Application/UserAPP/Coffee3CloseApp/Config/: coffee3_device_bindings.h
    ../Application/UserAPP/Coffee3CloseApp/Comm_Log/: coffee3_log.c coffee3_crash_log_port.c coffee3_retarget.c
    ../Application/UserAPP/Coffee3CloseApp/Device/: coffee3_device.c coffee3_device_image.c
    ../Application/UserAPP/Coffee3CloseApp/IO_State/: coffee3_io.c
    ../Application/UserAPP/Coffee3CloseApp/Modbus_Rtu_Bus/: coffee3_rtu_bus.c
    ../Application/UserAPP/Coffee3CloseApp/Robot_Tcp/: coffee3_robot_tcp.c
    ../Application/UserAPP/Coffee3CloseApp/Modbus_Tcp_Server/: coffee3_server.c
    ../Application/UserAPP/Coffee3CloseApp/WorkFlow/: coffee3_workflow.c
    ../Application/UserAPP/Coffee3CloseApp/Task_Manager/: coffee3_manager.c
    ../Application/UserAPP/Coffee3CloseApp/Ota/: coffee3_ota.c
  group Application/DeviceLibrary
    ../Application/DeviceLibrary/Robot/Dobot/: dobot_robot_device.c
    ../Application/DeviceLibrary/CoffeeMachine/: coffee_machine_f200.c coffee_machine_O.c coffee_machine_X.c coffee_machine_m50.c
    ../Application/DeviceLibrary/CupLidController/ShengShu/: cup_lid_shengshu.c
    ../Application/DeviceLibrary/SyrupMachine/CurrentModbus/: syrup_machine_modbus.c
    ../Application/DeviceLibrary/IceMachine/CurrentModbus/: ice_machine_modbus.c
    ../Application/DeviceLibrary/Scale/BSQ_DG_V2/: scale_bsq_dg_v2.c
    ../Application/DeviceLibrary/PowerMeter/DDSU666/: power_meter_ddsu666.c
    ../Application/DeviceLibrary/IoModule/ModbusDigitalIo/: io_module_modbus_digital.c
  group Application/Transport
    ../Application/Transport/Src/: transport.c transport_uart.c transport_tcp.c
  group Application/ProtocolStack/ModbusPort
    ../Application/ProtocolStack/ModbusPort/Src/: modbus_port.c
  group Application/New_Party/nanoMODBUS
    ../Application/New_Party/nanoMODBUS/Src/: nanomodbus.c
  group Application/User/LWIP/App
    ../CubeMX_Base/LWIP/App/: lwip.c
  group Drivers/BSP/Components
    ../CubeMX_Base/Drivers/BSP/Components/dp83848/: dp83848.c
  group Drivers/STM32F4xx_HAL_Driver
    ../CubeMX_Base/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_hal_crc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../CubeMX_Base/Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../CubeMX_Base/Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../CubeMX_Base/Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../CubeMX_Base/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../CubeMX_Base/Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../CubeMX_Base/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../CubeMX_Base/Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../CubeMX_Base/Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../CubeMX_Base/Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
target Coffee3Close (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: Coffee3Close +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_COFFEE3,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x0000C000U
  c misc: --preinclude ..\Application\UserAPP\Coffee3CloseApp\Config\coffee3_build_config.h
  c include: ../CubeMX_Base/Core/Inc;..\Application\Common;../Application/DeviceLibrary/Inc;../Application/DeviceLibrary/Robot/Dobot;../Application/DeviceLibrary/CoffeeMachine;../Application/DeviceLibrary/CupLidController/ShengShu;../Application/DeviceLibrary/SyrupMachine/CurrentModbus;../Application/DeviceLibrary/IceMachine/CurrentModbus;../Application/DeviceLibrary/Scale/BSQ_DG_V2;../Application/DeviceLibrary/PowerMeter/DDSU666;../Application/DeviceLibrary/IoModule/ModbusDigitalIo;../Application/Common/Diagnostics/Inc;../Application/Common/Diagnostics/Config;../Application/UserAPP/Coffee3CloseApp/Config;../Application/UserAPP/Coffee3CloseApp/Task_Manager;../Application/UserAPP/Coffee3CloseApp/Comm_Log;../Application/UserAPP/Coffee3CloseApp/Device;../Application/UserAPP/Coffee3CloseApp/IO_State;../Application/UserAPP/Coffee3CloseApp/Modbus_Rtu_Bus;../Application/UserAPP/Coffee3CloseApp/Robot_Tcp;../Application/UserAPP/Coffee3CloseApp/Modbus_Tcp_Server;../Application/UserAPP/Coffee3CloseApp/Ota;../Application/UserAPP/Coffee3CloseApp/WorkFlow;../Application/Transport/Inc;../Application/ProtocolStack/ModbusPort/Inc;../Application/ProtocolStack/ModbusPort/Config;..\Application\New_Party\nanoMODBUS\Inc;..\Application\New_Party\nanoMODBUS\Config;../CubeMX_Base/LWIP/App;../CubeMX_Base/LWIP/Target;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include;../CubeMX_Base/Middlewares/Third_Party/LwIP/system;../CubeMX_Base/Drivers/STM32F4xx_HAL_Driver/Inc;../CubeMX_Base/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/include;../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../CubeMX_Base/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../CubeMX_Base/Drivers/BSP/Components/dp83848;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/netif/ppp;../CubeMX_Base/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/lwip;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/lwip/apps;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/lwip/priv;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/lwip/prot;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/netif;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/compat/posix;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../CubeMX_Base/Middlewares/Third_Party/LwIP/src/include/compat/stdc;../CubeMX_Base/Middlewares/Third_Party/LwIP/system/arch;../CubeMX_Base/Drivers/CMSIS/Include
  asm include: ../CubeMX_Base/Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\ScatterFiles\Coffee3Close_CCM.sct
software components: CMSIS:CORE 4.3.0
